options:
  parameters:
    author: ctn008
    comment: |-
      channelDecoder & SpeechDecoder
      changed to SYNC_BLOCK
    generate_options: qt_gui
    id: tetraDMO_Decoder_v1
    output_language: python
    title: tetraDMO_Decoder_v1
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: next_view
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: view_step
  id: variable
  parameters:
    value: 512*1
  states: {}
- name: TETRA_DMO_MAC_DECODER_1
  id: TETRA_DMO_MAC_DECODER
  parameters:
    parametername_replace_me: You need to fill in your grc/TETRA_DMO_MAC_DECODER.block.yaml
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-2'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/von/test/output_sound/out_sound.out
    type: short
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/von/test/test_sample.uint8
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/von/new/tetraDMO-Receiver/DmoDecoder/tetraDMO_s36kBit_demod_samples.uint8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/von/test/speech_frame_window.uint8
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      sync block, 480 samples in, 480 samples out
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      IN_STEP = 432
      OUT_STEP = 276

      class tetraChDecoder(gr.basic_block):
          lib = cdll.LoadLibrary('/home/von/new/tetraDMO-Receiver/codec/tetraChDecoderLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.int16, 
                                                ndim=1,
                                                flags="C")
          lib.Channel_Decoding.argtypes = [c_int16, c_int16, ND_POINTER, ND_POINTER]
          lib.Channel_Decoding.restype = c_int16
          lib.Desinterleaving_Signalling.argtypes = [ND_POINTER, ND_POINTER]
          lib.Desinterleaving_Signalling.restype = c_int16
          lib.Desinterleaving_Speech.argtypes = [ND_POINTER, ND_POINTER]
          lib.Desinterleaving_Speech.restype = c_int16


          def Channel_Decoding(first_pass, Frame_Stealing, Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Channel_Decoding(first_pass, Frame_Stealing, Input_Frame, Output_Frame)
              return res

          def Desinterleaving_Signalling(Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Desinterleaving_Signalling(Input_Frame, Output_Frame)
              return res

          def Desinterleaving_Speech(Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Desinterleaving_Speech(Input_Frame, Output_Frame)
              return res
          
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Tetra ACELP\nChannel Decoder',   # will show up in GRC
                  in_sig =[np.uint8],
                  out_sig=[np.int16]
              )
              self.Loop_counter = 0
              self.first_pass = True
              self.Frame_stealing = False
              self.bfi1 = 0
              self.bfi2 = 0
              self.Reordered_array         = np.array([0]*286, dtype = 'int16')
              self.Interleaved_coded_array = np.array([0]*432, dtype = 'int16')
              self.Coded_array             = np.array([0]*432, dtype = 'int16')
           
          def general_work(self, input_items, output_items):
              in_index = 0
              out_index = 0

              while (len(input_items[0]) >= in_index + IN_STEP) and (len(output_items[0]) >= out_index + OUT_STEP) :

                  # "0" = 127, "1" = -127
                  if type(input_items[0][0]) == np.uint8:
                      for i in range(432):
                          self.Interleaved_coded_array[i] = -127 if input_items[0][in_index+i] else 127
                  else: #int16                   
                      self.Interleaved_coded_array[0:432] = input_items[0][in_index:in_index+432]
                                                              
                  #self.Frame_stealing = input_items[0][in_index + IN_STEP - 1]

                  if self.Frame_stealing :
                      tetraChDecoder.Desinterleaving_Signalling(self.Interleaved_coded_array[216:], self.Coded_array[216:])
                      self.Coded_array[:216] = self.Interleaved_coded_array[:216]
                  else:
                      tetraChDecoder.Desinterleaving_Speech(self.Interleaved_coded_array, self.Coded_array)

                  self.bfi1 = self.Frame_stealing
                  #if self.bfi1:
                  #    print(f"Frame Nb %d was stolen" %(self.Loop_counter+1))

                  bfi2 = tetraChDecoder.Channel_Decoding(self.first_pass, self.Frame_stealing, self.Coded_array, self.Reordered_array)
                  self.first_pass = False

                  if (self.Frame_stealing==0) and (self.bfi2==1):
                      self.bfi1 = 1

                  self.Loop_counter += 1
                  #if self.bfi2:
                  #    print(f"Frame Nb %d Bfi active" %(self.Loop_counter+1))

                  output_items[0][out_index] = self.bfi1
                  output_items[0][out_index+1:out_index+138] = self.Reordered_array[0:137]
                  output_items[0][out_index+138] = self.bfi2
                  output_items[0][out_index+139:out_index+276] = self.Reordered_array[137:274]

                  #if (not self.bfi1) and (not self.bfi2):
                  #    print(self.Loop_counter, "  full speech frame decoded ok")

                  in_index += IN_STEP
                  out_index += OUT_STEP
                  
              self.consume(0, in_index)
              return out_index
  states: {}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class frameStep(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, step = 4800, change = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Push_per_Frame',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.step= step
              self.change = change
              self.prechange = False

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              next_view = False
              if self.change != self.prechange :
                  #print("Next View")
                  next_view = True
                  self.prechange = self.change
              if next_view and (len(output_items[0]) >= self.step) and (len(input_items[0]) >= self.step):
                  output_items[0][:self.step] = input_items[0][:self.step]
                  #DEBUG output_txt = ''
                  #DEBUG for i in range(self.step):
                  #DEBUG output_txt += '1' if output_items[0][i] else '0'
                  self.consume(0, self.step)
                  #DEBUG print (output_txt)
                  return self.step
              else:
                  return 0
    change: next_view
    step: view_step
  states: {state: disabled}
- name: epy_block_0_2_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      L_FRAME     = 240
      SERIAL_SIZE = 138
      PRM_SIZE    = 24

      synth = np.array([0]*L_FRAME, dtype ='int16')      #/* Synthesis              */
      parm  = np.array([0]*PRM_SIZE, dtype ='int16')     #/* Synthesis parameters   */
      serial= np.array([0]*SERIAL_SIZE, dtype ='int16')  #/* Serial stream          */

      class tetraSpDecoder(gr.basic_block):
          lib = cdll.LoadLibrary('/home/von/new/tetraDMO-Receiver/codec/tetraSrcDecoderLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.int16, 
                                                ndim=1,
                                                flags="C")
          lib.Bits2prm_Tetra.argtypes = [ND_POINTER, ND_POINTER]
          lib.Decod_Tetra.argtypes    = [ND_POINTER, ND_POINTER]
          lib.Post_Process.argtypes   = [ND_POINTER, c_int16]

          def Init_Decod_Tetra():
              tetraSpDecoder.lib.Init_Decod_Tetra()
              
          def Bits2prm_Tetra(serial, parm):
              tetraSpDecoder.lib.Bits2prm_Tetra(serial, parm)

          def Decod_Tetra(parm, synth):
              tetraSpDecoder.lib.Decod_Tetra(parm, synth)

          def Post_Process(synth, L_frame):    
              tetraSpDecoder.lib.Post_Process(synth, L_frame)

          
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Tetra ACELP\nSpeech Decoder',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[np.float32]
              )
              self.frame = 0

          def general_work(self, input_items, output_items):
              cod_ptr = 0
              raw_ptr = 0

              tetraSpDecoder.Init_Decod_Tetra()
              while (cod_ptr + SERIAL_SIZE <= len(input_items[0])) and (raw_ptr + L_FRAME <= len(output_items[0])):

                  for j in range (SERIAL_SIZE):
                      serial[j] = input_items[0][cod_ptr+j]
                      
                  cod_ptr += SERIAL_SIZE
                  self.frame +=1
                  
                  #print("frame= %d" %self.frame)
                  tetraSpDecoder.Bits2prm_Tetra(serial, parm)
                  tetraSpDecoder.Decod_Tetra(parm, synth)
                  tetraSpDecoder.Post_Process(synth, L_FRAME)

                  for j in range (L_FRAME):
                      output_items[0][raw_ptr+j] = synth[j] / 32768
                  
                  raw_ptr += L_FRAME
              self.consume(0, cod_ptr)
              return raw_ptr
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      DSB = 1
      DNB = 2
      DNB_SF = 3
      INACTIVE = 0
      BURST_LEN = 510
      IN_STEP = 512
      OUT_STEP = 480

      class tetraTime():
          def __init__(self):
              self.tn = 1
              self.fn = 1
              self.mn = 1
          def timeIncrease(self):
              self.tn += 1
              if self.tn > 4:
                  self.tn -= 4
                  self.fn += 1
              if self.fn > 18:
                  self.fn -= 18
                  self.mn += 1
              
      class tetraCell():
          def __init__(self):
              self.m_mcc               = 0
              self.m_mnc               = 0
              self.m_colorCode         = 0
              self.m_scramblingCode    = 0
              self.m_locationArea      = 0

              self.m_downlinkFrequency = 0
              self.m_uplinkFrequency   = 0

              self.m_cellInformationsAcquired = False
              
          def updateScramblingCode(self, sourceAddress, mnIdentity): 
              self.m_mcc = mnIdentity >> 14
              self.m_mnc = mnIdentity & 0x3ff

              self.m_scramblingCode = sourceAddress | ((mnIdentity & 0x003f) << 24)
              self.m_scramblingCode = (self.m_scramblingCode << 2) | 0x0003

              self.m_cellInformationsAcquired = True

          def getScramblingCode(self):
              return self.m_scramblingCode

      class lowerMac(gr.basic_block):

          def __init__(self, lib= '/home/von/new/tetraDMO-Receiver/DmoDecoder/libs/codingLib.so'):
              gr.basic_block.__init__(
                  self,
                  name='serviceLowerMAC\nserviceUpperMAC',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.libname = lib
              self.burst_cnt = 0
              self.commType = 0

              self.m_tetraTime = tetraTime()
              self.m_tetraCell = tetraCell()
              self.m_sfStolenFlag = False
              
              self.fragFlag = 0
              self.destinAddrType = 0
              self.destinAddress  = 0
              self.sourceAddrType = 0
              self.sourceAddress  = 0
              self.mnIdentity     = 0

              self.ND_POINTER = np.ctypeslib.ndpointer(dtype=np.uint8, ndim=1,flags="C")
              self.lib = cdll.LoadLibrary(self.libname) # class level loading lib
              self.lib.descramble_raw.argtypes = [self.ND_POINTER, c_size_t, self.ND_POINTER, c_size_t, c_size_t]
              self.lib.descramble_raw.restype = c_size_t
              self.lib.deinterleave_raw.argtypes = [self.ND_POINTER, c_size_t, self.ND_POINTER, c_size_t, c_size_t]
              self.lib.deinterleave_raw.restype = c_size_t
              self.lib.depuncture23_raw.argtypes = [self.ND_POINTER, c_size_t, self.ND_POINTER, c_size_t]
              self.lib.depuncture23_raw.restype = c_size_t
              self.lib.viterbiDecode1614_raw.argtypes = [self.ND_POINTER, c_size_t, self.ND_POINTER]
              self.lib.viterbiDecode1614_raw.restype = c_size_t
              self.lib.checkCrc16Ccitt_raw.argtypes = [self.ND_POINTER, c_size_t, c_size_t]
              self.lib.checkCrc16Ccitt_raw.restype = c_bool
          

          def descramble(self, data, size, scramblingCode):
              res = np.array([0]*size, dtype='uint8')
              res_len = self.lib.descramble_raw(data, len(data), res, size, scramblingCode)
              return res

          def deinterleave(self, data, K, a):
              res = np.array([0]*K, dtype='uint8')
              res_len = self.lib.deinterleave_raw(data, len(data), res, K, a)
              return res
              
          def depuncture23(self, data, length):
              res = np.array([0]*(4*length*2//3), dtype='uint8')
              res_len = self.lib.depuncture23_raw(data, len(data), res, length)
              return res

          def viterbiDecode1614(self, data):
              res = np.array([0]*(len(data)//4), dtype='uint8')
              res_len = self.lib.viterbiDecode1614_raw(data, len(data), res)
              return res

          def checkCrc16Ccitt(self, data, length):
              res_value = self.lib.checkCrc16Ccitt_raw(data, len(data), length)
              return res_value

          def getValue(pdu, pos, len):
              temp = 0
              for i in range(len):
                  temp = temp * 2 + pdu[pos+i]
              return temp
          
                 
          def processDmacSync(self, pdu):
              self.commType       = lowerMac.getValue(pdu, 6, 2)
              self.m_tetraTime.tn = lowerMac.getValue(pdu, 12, 2) + 1
              self.m_tetraTime.fn = lowerMac.getValue(pdu, 14, 5)
              self.fragFlag       = lowerMac.getValue(pdu, 71, 1)

              #DEBUG print("TN:FN", self.m_tetraTime.tn,':', self.m_tetraTime.fn, " fragFlag: ", self.fragFlag)
              
              pos = 76 if self.fragFlag else 72
              self.frameCntDn     = lowerMac.getValue(pdu, pos, 2)
              pos += 2
              self.destinAddrType = lowerMac.getValue(pdu, pos, 2)
              pos += 2
              if self.destinAddrType != 2:
                  self.destinAddress = lowerMac.getValue(pdu, pos, 24)
                  pos += 24
              self.sourceAddrType = lowerMac.getValue(pdu, pos, 2)
              pos += 2
              if self.sourceAddrType != 2:
                  self.sourceAddress = lowerMac.getValue(pdu, pos, 24)
                  pos += 24
              if (self.commType == 0) or (self.commType == 1):
                  self.mnIdentity = lowerMac.getValue(pdu, pos, 24)
                  pos += 24
              if self.mnIdentity and self.sourceAddress :
                  print("scrambling code is: ", self.m_tetraCell.getScramblingCode())
                  self.m_tetraCell.updateScramblingCode(self.sourceAddress, self.mnIdentity)

              #DEBUG print("Scrambling code: ", hex(self.m_tetraCell.getScramblingCode()) )
              #DEBUG print("Source address: ", self.sourceAddress, "Destin address: ", self.destinAddress)
              
          def general_work(self, input_items, output_items):
              in_index = 0
              out_index = 0
              while (len(input_items[0]) >= in_index + IN_STEP) and (len(output_items[0]) >= out_index + OUT_STEP):
                  # print("MN:FN:TN = ", self.m_tetraTime.mn,":",self.m_tetraTime.fn,":",self.m_tetraTime.tn, " ", end ='')
                  if input_items[0][in_index+BURST_LEN] == DSB:
                      bkn1 = np.array(input_items[0][in_index+34+94 :in_index+34+94 +120])
                      bkn2 = np.array(input_items[0][in_index+34+252:in_index+34+252+216])

                      bkn1 = self.descramble(bkn1, 120, 0x03)
                      bkn1 = self.deinterleave(bkn1, 120, 11)
                      bkn1 = self.depuncture23(bkn1, 120)
                      bkn1 = self.viterbiDecode1614(bkn1)

                      bkn2 = self.descramble(bkn2, 216, 0x03)
                      bkn2 = self.deinterleave(bkn2, 216, 101)
                      bkn2 = self.depuncture23(bkn2, 216)
                      bkn2 = self.viterbiDecode1614(bkn2)

                      bkn1crc = self.checkCrc16Ccitt(bkn1, 76)
                      bkn2crc = self.checkCrc16Ccitt(bkn2, 140)
                      
                      if (bkn1crc==False) or (bkn2crc==False):
                          pass
                          print("DSB ", "CRC: ", bkn1crc, bkn2crc)
                      else:
                          print("DSB")
                          bkn1 = np.concatenate((bkn1[:60], bkn2[:124]))
                          self.processDmacSync( bkn1 )
                      print("input_items: ", in_index, "\n")
                      print("output_items: ", out_index, "\n")

                          
                  elif input_items[0][in_index+BURST_LEN] == DNB:
                      bkn1 = np.array(input_items[0][in_index+34+14 :in_index+34+14 +216])
                      bkn2 = np.array(input_items[0][in_index+34+252:in_index+34+252+216])
                      bkn1 = np.concatenate((bkn1, bkn2))
                      bkn1 = self.descramble(bkn1, 432, self.m_tetraCell.getScramblingCode())
                      
                      print("DNB")
                      output_items[0][out_index:out_index+len(bkn1)] = bkn1
                      out_index += OUT_STEP
                      output_items[0][out_index-1] = 0 # set SPEECH FRAME

                  elif input_items[0][in_index+BURST_LEN] == DNB_SF:
                      bkn1ValidFlag = False
                      bkn2ValidFlag = False

                      # BKN1 block - DMAC STCH 
                      bkn1 = np.array(input_items[0][in_index+34+14 :in_index+34+14 +216])
                      bkn1 = self.descramble(bkn1, 216, self.m_tetraCell.getScramblingCode())
                      bkn1 = self.deinterleave(bkn1, 216, 101)                                 
                      bkn1 = self.depuncture23(bkn1, 216)                                      
                      bkn1 = self.viterbiDecode1614(bkn1)                                      
                      if (self.checkCrc16Ccitt(bkn1, 140)) :
                          bkn1 = np.array(bkn1[:124])
                          bkn1ValidFlag = True

                      # BKN2 block - DMAC STCH or TCH/S
                      bkn2 = np.array(input_items[0][in_index+34+252:in_index+34+252+216])
                      bkn2 = self.descramble(bkn2, 216, self.m_tetraCell.getScramblingCode())
                      bkn2_uplane = np.array(bkn2)
                      bkn2 = self.deinterleave(bkn2, 216, 101)
                      bkn2 = self.depuncture23(bkn2, 216)
                      bkn2 = self.viterbiDecode1614(bkn2)         
                      if (self.checkCrc16Ccitt(bkn2, 140)):         # check CRC if FALSE ==> TCH/S
                          bkn2 = np.array(bkn2[:124])
                          bkn2ValidFlag = True

                      print("DNB_SF")
                  
                      if (bkn1ValidFlag):
                          pass # serviceUpperMac(Pdu(bkn1), DSTCH);                               // first block is stolen for C or U signalling
                      else:    # for debug purpose - display if CRC errors found
                          print(f"DNB_SF Burst CRC check errors found BKN1 TN/FN/MN: %u/%u/%u. \n\n" % (self.m_tetraTime.tn, self.m_tetraTime.fn, self.m_tetraTime.mn))
                      
                      output_items[0][out_index:out_index+OUT_STEP] = np.array([0]*OUT_STEP, dtype='uint8')
                      
                      if (self.m_sfStolenFlag):        # if second-half slot is also stolen
                          if (bkn2ValidFlag):
                              pass #serviceUpperMac(Pdu(bkn2), DSTCH);                           // second block also stolen, reset flag
                          else:
                              print(f"DNB_SF Burst CRC check errors found BKN2 TN/FN/MN: %u/%u/%u. \n\n" %(self.m_tetraTime.tn, self.m_tetraTime.fn, self.m_tetraTime.mn))                    
                      else:
                          output_items[0][out_index+216:out_index+432] = bkn2_uplane
                      print("input_items: ", in_index, "\n")
                      print("output_items: ", out_index, "\n")
                      out_index += OUT_STEP
                      output_items[0][out_index-1] = 1 # set STOLEN FRAME                
                  else:
                      pass
                      #DEBUG print("Inactive")

                  in_index += IN_STEP
                  self.burst_cnt += 1
                  self.m_tetraTime.timeIncrease()

              self.consume(0, in_index) #consume port 0 input
              return out_index
    lib: '''/home/von/new/tetraDMO-Receiver/DmoDecoder/libs/codingLib.so'''
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      class blk(gr.basic_block):
          codingLib = cdll.LoadLibrary('/home/von/new/tetraDMO-Receiver/DmoDecoder/libs/codingLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.uint8, 
                                            ndim=1,
                                            flags="C")
          def service_mac(in_data, in_len, out_data):
              blk.codingLib.service_mac.argtypes = [blk.ND_POINTER, c_size_t, blk.ND_POINTER]
              blk.codingLib.service_mac.restype = c_size_t
              res = blk.codingLib.service_mac(in_data, in_len, out_data)
              return res


          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='DMO\nBurst SYNC',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

          def general_work(self, input_items, output_items):
              in_len = len(input_items[0])
              out_len = len(output_items[0])
              consume_len = in_len if (in_len < (out_len - 510)) else (out_len - 510)
              out_items = blk.service_mac(input_items[0], consume_len, output_items[0])
              self.consume(0, consume_len)
              return out_items
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: audio
    name: '"speech output"'
    size: '2000'
    srate: audio_rate
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: audio
    name: '"frame"'
    size: 520*4
    srate: audio_rate
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: audio
    name: '"frame_testing"'
    size: '1024'
    srate: audio_rate
    type: float
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}

connections:
- [TETRA_DMO_MAC_DECODER_1, '0', epy_block_0_0_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_char_to_float_2, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_file_source_0, '0', TETRA_DMO_MAC_DECODER_1, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_2, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_1, '0', epy_block_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_throttle2_0, '0', TETRA_DMO_MAC_DECODER_1, '0']
- [blocks_throttle2_0, '0', blocks_char_to_float_2, '0']
- [blocks_throttle2_0, '0', epy_block_2, '0']
- [epy_block_0_0_0, '0', blocks_file_sink_0, '0']
- [epy_block_0_0_0, '0', epy_block_0_2_0_0, '0']
- [epy_block_0_1_0_0, '0', epy_block_1, '0']
- [epy_block_0_2_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_1, '0', blocks_char_to_float_0, '0']
- [epy_block_2, '0', blocks_char_to_float_1, '0']
- [epy_block_2, '0', epy_block_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
