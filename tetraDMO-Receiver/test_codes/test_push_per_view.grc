options:
  parameters:
    generate_options: qt_gui
    id: test_push_per_view
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: next_view
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: view_step
  id: variable
  parameters:
    value: 520*1
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: ([0]*view_step+[1]*(view_step//2) +[2]*(view_step//2) +[3]*(view_step//2)+[4]*(view_step //2 ) )
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class frameStep(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, step = 4800, change = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Push_per_Frame',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.step= step
              self.change = change
              self.prechange = False

          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              next_view = False
              if self.change != self.prechange :
                  #print("Next View")
                  next_view = True
                  self.prechange = self.change
              if next_view and (len(output_items[0]) >= self.step) and (len(input_items[0]) >= self.step):
                  output_items[0][:self.step] = input_items[0][:self.step]
                  #DEBUG output_txt = ''
                  #DEBUG for i in range(self.step):
                  #DEBUG output_txt += '1' if output_items[0][i] else '0'
                  self.consume(0, self.step)
                  #DEBUG print (output_txt)
                  return self.step
              else:
                  return 0
    change: next_view
    step: view_step
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Push per Frame
    marker1: '0'
    name: '"Push per Frame"'
    size: view_step
    srate: samp_rate
    type: float
    ymax: '3.2'
    ymin: '-0.2'
  states: {}

connections:
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0, '0', epy_block_0_1_0, '0']
- [epy_block_0_1_0, '0', blocks_char_to_float_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
