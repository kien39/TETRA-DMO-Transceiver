options:
  parameters:
    generate_options: qt_gui
    id: Tx_pi4dqpsk_Modulator
    output_language: python
    title: Tx_pi4dqpsk_Modulator
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: frequency_hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,0]'
    label: Frequency [Hz]
    type: real
    value: '390000000'
  states: {}
- name: num_tap
  id: variable
  parameters:
    value: '11'
  states: {}
- name: pluto_freq_offset
  id: variable_qtgui_range
  parameters:
    start: '-5000'
    step: '100'
    stop: '5000'
    value: '3800'
  states: {}
- name: pttButton
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 80000*decim
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '18000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ctn008/tetraDMO-Transmitter/TxDMO_s36kIQ.complex64
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/ctn008/tetraDMO-Transmitter/samples/tetraDMO_s36kBit_tx.uint8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/ctn008/0.Pluto/pluto_04_analysis/TxDMO_pluto_04_s36kIQ.complex64
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samp_per_symbol
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: samp_per_symbol
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: symbol_rate*2
    type: byte
  states: {state: bypassed}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1]+ [0]*(samp_per_symbol-1)'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block): 
          def __init__(self, pttStatus=False):  
              gr.sync_block.__init__(
                  self,
                  name='PTT_Control',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.pttStatus = pttStatus

          def work(self, input_items, output_items):
              if self.pttStatus:
                  output_items[0][:] = input_items[0]
                  return len(output_items[0])
              else:
                  return 0
    pttStatus: pttButton
  states: {state: bypassed}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      IN_STEP = 510
      OUT_STEP = 510

      class dmoBurst_iqMapper(gr.basic_block):  
          # Phase Index Change Table: corresponding to current phase (row 0-7) and current dibit value (column 0-3)
          # B2k_1,B2k:   00 01 10 11
          phase_shift = (1, 3, 7, 5)

          # Phase value corresponding to Phase Index
          IQ_table = (( np.cos(np.pi/4 * 0) , np.sin(np.pi/4 * 0) ),
                      ( np.cos(np.pi/4 * 1) , np.sin(np.pi/4 * 1) ),
                      ( np.cos(np.pi/4 * 2) , np.sin(np.pi/4 * 2) ),
                      ( np.cos(np.pi/4 * 3) , np.sin(np.pi/4 * 3) ),
                      ( np.cos(np.pi/4 * 4) , np.sin(np.pi/4 * 4) ),
                      ( np.cos(np.pi/4 * 5) , np.sin(np.pi/4 * 5) ),
                      ( np.cos(np.pi/4 * 6) , np.sin(np.pi/4 * 6) ),
                      ( np.cos(np.pi/4 * 7) , np.sin(np.pi/4 * 7) ))

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='dmoBurst_iqMapper',
                  in_sig=[np.uint8],
                  out_sig=[np.float32, np.float32]
              )
              self.cur_phase_index = 	0				# current phase index value S(0) = 1

          def general_work(self, input_items, output_items):
              in_index = 0
              out_index = 0
              while ( (len(input_items[0])-in_index) >= IN_STEP) and ( (len(output_items[0])-out_index) >= OUT_STEP):
                  print("Burst type: ", input_items[0][in_index])
                  for i in range (510):
                      self.cur_phase_index += dmoBurst_iqMapper.phase_shift[ input_items[0][in_index+i+10] ]
                      if self.cur_phase_index >= 8:
                          self.cur_phase_index -= 8
                      output_items[0][out_index+i] = dmoBurst_iqMapper.IQ_table[ self.cur_phase_index ][0]
                      output_items[1][out_index+i] = dmoBurst_iqMapper.IQ_table[ self.cur_phase_index ][1]
                  """
                  if ( input_items[0][in_index] ):   # active burst, either DSB, DNB or DNB_SF
                      for i in range (510):
                          self.cur_phase_index += dmoBurst_iqMapper.phase_shift[ input_items[0][in_index+i+10] ]
                          if self.cur_phase_index >= 8:
                              self.cur_phase_index -= 8
                          output_items[0][out_index+i] = dmoBurst_iqMapper.IQ_table[ self.cur_phase_index ][0]
                          output_items[1][out_index+i] = dmoBurst_iqMapper.IQ_table[ self.cur_phase_index ][1]
                  else:
                      for i in range (510):
                          output_items[0][out_index+i] = 0.0
                          output_items[1][out_index+i] = 0.0
                  """
                  in_index += IN_STEP
                  out_index += OUT_STEP
              self.consume(0, in_index)
              return out_index
    comment: 'in: 520, out: 510'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='NOT WORKING IN REALTIME\nOFFLINE PLEASE TEST',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '2000000'
    buffer_size: int(32768)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: frequency_hz + pluto_freq_offset
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    gain: decim*3/4
    interp: decim
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 36/80
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"s36kIQ signal "'
    size: '5100'
    srate: symbol_rate*2
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"IQ signal after interpolation"'
    size: 13500*32
    srate: (samp_rate)
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: samp_per_symbol
    ntaps: num_tap*samp_per_symbol
    samp_rate: samp_per_symbol*symbol_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: samp_per_symbol
    ntaps: num_tap*samp_per_symbol
    samp_rate: samp_per_symbol*symbol_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}

connections:
- [blocks_file_source_0_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', epy_block_0, '0']
- [blocks_multiply_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_throttle2_0_0, '0', epy_block_1, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0_0, '0']
- [epy_block_0, '0', mmse_resampler_xx_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_1, '0', blocks_repeat_0, '0']
- [epy_block_1, '1', blocks_repeat_0_0, '0']
- [low_pass_filter_0_0, '0', iio_pluto_sink_0, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_complex_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
