options:
  parameters:
    generate_options: qt_gui
    id: plutoTx390mhz_Transmitter
    output_language: python
    title: plutoTx390mhz_Transmitter
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: envelope_in
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: freq_adjust
  id: variable_qtgui_range
  parameters:
    start: '-7000'
    step: '10'
    stop: '7000'
    value: '3400'
  states: {}
- name: frequency_hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,0]'
    label: Frequency [Hz]
    type: real
    value: '390000000'
  states: {}
- name: num_tap
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 80000*decim
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '18000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ctn008/0.Pluto/pluto_04_analysis/TxDMO_pluto_04_s36kIQ.complex64
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/ctn008/0.Pluto/pluto_05_analysis/RxDMO_pluto_to_s18kDibit_05.uint8
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/ctn008/0.Pluto/pluto_04_analysis/TxDMO_pluto_to_s18kDibit_Envelope.uint8
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0_0_1
  id: blocks_file_source
  parameters:
    file: /home/ctn008/tetraDMO-Transmitter/samples/tetraDMO_s36kBit_tx.uint8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0_1
  id: blocks_file_source
  parameters:
    file: //home/ctn008/0.Pluto/pluto_04_analysis/TxDMO_pluto_04_s36kIQ.complex64
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[3]*180000'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class Pi4DQPSK(gr.interp_block):
          # Create our raised-cosine filter
          num_taps = 11 * 2 + 1
          beta = 0.35
          Ts = 2
          t = np.arange(num_taps) - (num_taps-1) // 2
          h = np.sinc(t/Ts) * np.cos(np.pi*beta*t/Ts) / (1 - (2*beta*t/Ts)**2)
          preConvI = np.array([0] * 22, dtype = 'float32')
          preConvQ = np.array([0] * 22, dtype = 'float32')
          
          def __init__(self, envelope_in = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.interp_block.__init__(
                  self,
                  name='Pi4DQPSK 18kDibit-to-36kIQk',   	# will show up in GRC
                  in_sig=[np.uint8, np.uint8,],
                  out_sig=[np.complex64], interp = 2
              )
              self.interp = 2        
              self.cur_phase_index = 	0				# current phase index value S(0) = 1
              self.envelope_in = envelope_in
              
          def work(self, input_items, output_items):
              # Phase Index Change Table: corresponding to current phase (row 0-7) and current dibit value (column 0-3)
              # B2k_1,B2k:   00 01 10 11
                  
              phase_shift = (1, 3, 7, 5)

              # Phase value corresponding to Phase Index
              IQ_table = (( np.cos(np.pi/4 * 0) , np.sin(np.pi/4 * 0) ),
                          ( np.cos(np.pi/4 * 1) , np.sin(np.pi/4 * 1) ),
                          ( np.cos(np.pi/4 * 2) , np.sin(np.pi/4 * 2) ),
                          ( np.cos(np.pi/4 * 3) , np.sin(np.pi/4 * 3) ),
                          ( np.cos(np.pi/4 * 4) , np.sin(np.pi/4 * 4) ),
                          ( np.cos(np.pi/4 * 5) , np.sin(np.pi/4 * 5) ),
                          ( np.cos(np.pi/4 * 6) , np.sin(np.pi/4 * 6) ),
                          ( np.cos(np.pi/4 * 7) , np.sin(np.pi/4 * 7) ))

      		# process first sample - set initial phase
              """ self.cur_phase_index += phase_shift[ 0 ]	# don't take the 1st input - due to error ???
              if self.cur_phase_index >= 8:
                  self.cur_phase_index -= 8
              output_items[0][0] = IQ_table[ self.cur_phase_index ][0]
              output_items[1][0] = IQ_table[ self.cur_phase_index ][1]
      		"""
              # perform rrc filter
              tempI = np.array([0] * (len(input_items[0]) * 2), dtype='float32') # 22 = rrc_taps - 1
              tempQ = np.array([0] * (len(input_items[0]) * 2), dtype='float32') # 22 = rrc_taps - 1

              for i in range (0,len(input_items[0])):
                  if self.envelope_in:
                      input_dibit = input_items[0][i] & input_items[1][i]
                  else:
                      input_dibit = input_items[0][i]
                      
                  self.cur_phase_index += phase_shift[ input_dibit ]
                  if self.cur_phase_index >= 8:
                      self.cur_phase_index -= 8

                  if input_items[1][i] :
                      tempI[i*2] = IQ_table[ self.cur_phase_index ][0]
                      tempQ[i*2] = IQ_table[ self.cur_phase_index ][1]

              tempIconvolved = np.convolve(tempI, Pi4DQPSK.h) 
              tempQconvolved = np.convolve(tempQ, Pi4DQPSK.h)
              
              for i in range(len(Pi4DQPSK.h)-1):
                  tempIconvolved[i] += Pi4DQPSK.preConvI[i]
                  tempQconvolved[i] += Pi4DQPSK.preConvQ[i]

              for i in range(len(Pi4DQPSK.h)-1):
                  Pi4DQPSK.preConvI[-i-1] = tempIconvolved[-i-1]
                  Pi4DQPSK.preConvQ[-i-1] = tempQconvolved[-i-1]
              for i in range(len(input_items[0])*2):
                  output_items[0][i] = tempIconvolved [i] + 1j*tempQconvolved[i]
                                         
              return len(output_items[0])
    envelope_in: envelope_in
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '2000000'
    buffer_size: int(32768)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: frequency_hz+freq_adjust
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    gain: decim/2
    interp: decim
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 36/80
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '4080'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [blocks_file_source_0_0_0, '0', epy_block_1, '0']
- [blocks_file_source_0_0_0_0, '0', epy_block_1, '1']
- [blocks_file_source_0_0_0_1, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_file_source_0_0_1, '0', mmse_resampler_xx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_source_x_0, '0', epy_block_1, '1']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_throttle2_0, '0']
- [low_pass_filter_0_0, '0', iio_pluto_sink_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
