options:
  parameters:
    generate_options: qt_gui
    id: pluto_DmoTxRx_v0_0
    output_language: python
    title: pluto_DmoTxRx_v0_0
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1-1j, 1+1j, -1-1j, 1-1j]'
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {}
- name: decim
  id: variable
  parameters:
    value: '16'
  states: {}
- name: freq_adjust
  id: variable_qtgui_range
  parameters:
    gui_hint: freq_parameters
    start: '-7000'
    step: '10'
    stop: '7000'
    value: '4000'
  states: {}
- name: freq_offset_hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: freq_parameters
    label: Baseband offset_Hz
    type: real
    value: '45000'
  states: {}
- name: frequency_hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: freq_parameters
    label: Frequency [Hz]
    type: real
    value: '390000000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_tap
  id: variable
  parameters:
    value: '11'
  states: {}
- name: ptt_on
  id: variable_qtgui_push_button
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Push_To_Talk
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 80000*decim
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '18000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: constel
    modulus: '1'
    step_size: '10e-3'
    type: cma
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: cmath.pi/100.0
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: sps
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_code()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*cmath.pi/100.0
    max_dev: '1.5'
    osps: sps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: tetraDmoEncoder

      perform encoding Dmo tetra signal
      - input: 432 byte frames voice signal one per 4 time slot per 17 frame
      - output 510 byte tetra burst signal, 4 per frame per 18 frame
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *
      import pmt

      class DmoEncoder(gr.basic_block):

          MacEncoderLib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Transmitter/libs/MacEncoderLib_v1.so')
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.uint8, 
                                                    ndim=1,
                                                    flags="C")
          def Init_serviceMacEncode(show_txt, talkgroup_id, radio_id):
              DmoEncoder.MacEncoderLib.Init_serviceMacEncode.argtypes = [c_bool, c_size_t, c_size_t]
              DmoEncoder.MacEncoderLib.Init_serviceMacEncode(show_txt, talkgroup_id, radio_id)
            
          def serviceMacEncode(showTxt, ptt, talkgroup_id, radio_id, in_data, in_len, out_data, out_envelop):
              DmoEncoder.MacEncoderLib.serviceMacEncode.argtypes = [c_bool, c_bool, c_size_t, c_size_t, DmoEncoder.ND_POINTER, c_size_t, DmoEncoder.ND_POINTER, DmoEncoder.ND_POINTER]
              DmoEncoder.MacEncoderLib.serviceMacEncode.restype = c_size_t
              res = DmoEncoder.MacEncoderLib.serviceMacEncode(showTxt, ptt, talkgroup_id, radio_id, in_data, in_len, out_data, out_envelop)
              return res
          
          def __init__(self, show_txt=True, talkgroup_id = 1001, radio_id =6081751, ptt = False):
              gr.basic_block.__init__(
                  self,
                  name='TetraDMO Encoder',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8, np.uint8]
              )
              self.showTxt        = show_txt
              self.prev_showTxt    = False
              self.update_showTxt = False
              self.talkgroupId    = talkgroup_id
              self.radioId        = radio_id
              self.ptt            = ptt
              self.prev_ptt       = False
              self.update_ptt     = False

              self.message_port_register_in(pmt.intern('ptt'))
              self.set_msg_handler(pmt.intern('ptt'), self.handle_msg)

              self.message_port_register_out(pmt.intern('tx_keyed'))
              self.tx_keyed_status = pmt.cons( pmt.intern('tx_keyed'), pmt.from_bool(False) )

          def handle_msg(self, msg):
              # rotate curChannel + 1
              #self.ptt = True       
              print(msg)
              
          def general_work(self, input_items, output_items):
              if self.showTxt != self.prev_showTxt:
                  self.prev_showTxt = self.showTxt
                  self.update_showTxt = True
              if self.update_showTxt:
                  self.update_showTxt = False
                  print("showTxt = ", self.ptt)
              
              in_len  = len(input_items[0])
              out_len = len(output_items[0])
              in_ptr = 0
              out_ptr = 0

              in_ptr  = in_len if (out_len*2-255) >= (in_len*5) else (out_len*2-255)//5
              out_ptr = DmoEncoder.serviceMacEncode(self.showTxt, self.ptt, self.talkgroupId, self.radioId, input_items[0], in_ptr, output_items[0], output_items[1])

              self.consume(0, in_ptr)
              return out_ptr
    ptt: ptt_on
    radio_id: '6081751'
    show_txt: 'False'
    talkgroup_id: '1001'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      sync block, 480 samples in, 480 samples out
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      IN_STEP = 480
      OUT_STEP = 432
      L_FRAME     = 240
      SERIAL_SIZE = 138
      ANA_SIZE    =  23

      class SrcChCoder(gr.basic_block):
          SrcCoderlib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Transmitter/libs/tetraSrcCoderLib.so')

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.int16, 
                                                ndim=1,
                                                flags="C")
          SrcCoderlib.Pre_Process.argtypes = [ND_POINTER, c_int16]
          SrcCoderlib.Prm2bits_Tetra.argtypes = [ND_POINTER, ND_POINTER]
          SrcCoderlib.Coder_Tetra.argtypes    = [ND_POINTER, ND_POINTER]
          SrcCoderlib.Post_Process.argtypes   = [ND_POINTER, c_int16]

          SrcCoderlib.Copy_Speech_Frame.argtypes   = [ND_POINTER]
          def Copy_Speech_Frame(speech_frame):
              SrcChCoder.SrcCoderlib.Copy_Speech_Frame(speech_frame)

          def Init_Pre_Process():
              SrcChCoder.SrcCoderlib.Init_Pre_Process()

          def Init_Coder_Tetra():
              SrcChCoder.SrcCoderlib.Init_Coder_Tetra()
              
          def Pre_Process(new_speech, L_frame):
              SrcChCoder.SrcCoderlib.Pre_Process(new_speech, L_frame)

          def Prm2bits_Tetra(ana, serial):
              SrcChCoder.SrcCoderlib.Prm2bits_Tetra(ana, serial)

          def Coder_Tetra(ana, syn):
              SrcChCoder.SrcCoderlib.Coder_Tetra(ana, syn)

          def Post_Process(synth, L_frame):    
              SrcChCoder.SrcCoderlib.Post_Process(synth, L_frame)

          ChCoderlib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Transmitter/libs/tetraChCoderLib.so')

          ChCoderlib.Channel_Encoding.argtypes    = [c_int16, c_int16, ND_POINTER, ND_POINTER]
          ChCoderlib.Interleaving_Signalling.argtypes = [ND_POINTER, ND_POINTER]
          ChCoderlib.Interleaving_Signalling.restype  = c_int16
          ChCoderlib.Interleaving_Speech.argtypes     = [ND_POINTER, ND_POINTER]
          ChCoderlib.Interleaving_Speech.restype      = c_int16

          def Channel_Encoding(first_pass, FS_Flag, Vocod_array, Coded_array):
              SrcChCoder.ChCoderlib.Channel_Encoding(first_pass,FS_Flag,Vocod_array,Coded_array)

          def Interleaving_Signalling( Input_Frame, Output_frame ):
              return SrcChCoder.ChCoderlib.Interleaving_Signalling( Input_Frame, Output_frame )

          def Interleaving_Speech( Input_Frame, Output_frame ):
              return SrcChCoder.ChCoderlib.Interleaving_Speech( Input_Frame, Output_frame )
          
          def __init__(self, mic_gain = 1):
              gr.basic_block.__init__(
                  self,
                  name='Tetra Voice Coder',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.uint8]
              )
              self.mic_gain = mic_gain
              
              self.syn    = np.array([0]*L_FRAME,     dtype = 'int16')
              self.ana    = np.array([0]*ANA_SIZE,    dtype = 'int16')    #/* Analysis parameters.   */
              self.serial = np.array([0]*SERIAL_SIZE, dtype = 'int16') #/* Serial stream.         */

              self.Loop_counter = 0
              self.first_pass = True
              self.FS_Flag = False
              self.Vocod_array         = np.array([0]*274, dtype = 'int16')
              self.Coded_array             = np.array([0]*432, dtype = 'int16')
              self.Interleaved_coded_array = np.array([0]*432, dtype = 'int16')

              SrcChCoder.Init_Pre_Process()
              SrcChCoder.Init_Coder_Tetra()
           
          def general_work(self, input_items, output_items):
              in_index = 0
              out_index = 0

              frame = 0

              while (len(input_items[0]) >= in_index + IN_STEP) and (len(output_items[0]) >= out_index + OUT_STEP) :
                  # multiply 32768 to convert from floating to int16
                  new_speech = np.array(input_items[0][in_index:in_index+480]*32768 * self.mic_gain, dtype = 'int16')
                  # process 1st 240 samples
                  SrcChCoder.Pre_Process(new_speech, L_FRAME)
                  SrcChCoder.Copy_Speech_Frame(new_speech)    # copy to c global 'new_speech' pointer
                  SrcChCoder.Coder_Tetra(self.ana, self.syn)
                  SrcChCoder.Post_Process(self.syn, L_FRAME)
                  SrcChCoder.Prm2bits_Tetra(self.ana, self.serial)
                  self.Vocod_array[  0:137] = self.serial[1:SERIAL_SIZE]
                  
                  # process next 240 samples
                  SrcChCoder.Pre_Process(new_speech[240:], L_FRAME)
                  SrcChCoder.Copy_Speech_Frame(new_speech[240:])    # copy to c global 'new_speech' pointer
                  SrcChCoder.Coder_Tetra(self.ana, self.syn)
                  SrcChCoder.Post_Process(self.syn, L_FRAME)
                  SrcChCoder.Prm2bits_Tetra(self.ana, self.serial)
                  self.Vocod_array[137:274] = self.serial[1:SERIAL_SIZE]

                  SrcChCoder.Channel_Encoding(self.first_pass, self.FS_Flag, self.Vocod_array, self.Coded_array)
                  self.first_pass = False

                  if (not self.FS_Flag):
                      SrcChCoder.Interleaving_Speech(self.Coded_array, self.Interleaved_coded_array)
                  else:
                      SrcChCoder.Interleaving_Signalling( self.Coded_array[216:], self.Interleaved_coded_array[216:] )
                      self.Interleaved_coded_array[0:216] = self.Coded_array[0:216]
                      print("FS_Flag ON")
                          
                  self.Loop_counter += 1

                  if type(output_items[0][0]) == np.int16:
                      output_items[0][out_index:out_index+432] = self.Interleaved_coded_array
                  else: #uint8
                      for i in range(432):
                          output_items[0][out_index+i] = 0 if (self.Interleaved_coded_array[i] == 127) else 1

                  in_index += IN_STEP
                  out_index += OUT_STEP
                  
              self.consume(0, in_index)
              return out_index
    mic_gain: '4'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      sync block, 480 samples in, 480 samples out
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      IN_STEP = 432
      OUT_STEP = 276

      class tetraChDecoder(gr.basic_block):
          lib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Receiver/codec/tetraChDecoderLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.int16, 
                                                ndim=1,
                                                flags="C")
          lib.Channel_Decoding.argtypes = [c_int16, c_int16, ND_POINTER, ND_POINTER]
          lib.Channel_Decoding.restype = c_int16
          lib.Desinterleaving_Signalling.argtypes = [ND_POINTER, ND_POINTER]
          lib.Desinterleaving_Signalling.restype = c_int16
          lib.Desinterleaving_Speech.argtypes = [ND_POINTER, ND_POINTER]
          lib.Desinterleaving_Speech.restype = c_int16


          def Channel_Decoding(first_pass, Frame_Stealing, Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Channel_Decoding(first_pass, Frame_Stealing, Input_Frame, Output_Frame)
              return res

          def Desinterleaving_Signalling(Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Desinterleaving_Signalling(Input_Frame, Output_Frame)
              return res

          def Desinterleaving_Speech(Input_Frame, Output_Frame):
              res = tetraChDecoder.lib.Desinterleaving_Speech(Input_Frame, Output_Frame)
              return res
          
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Tetra ACELP\nChannel Decoder',   # will show up in GRC
                  in_sig =[np.uint8],
                  out_sig=[np.int16]
              )
              self.Loop_counter = 0
              self.first_pass = True
              self.Frame_stealing = False
              self.bfi1 = 0
              self.bfi2 = 0
              self.Reordered_array         = np.array([0]*286, dtype = 'int16')
              self.Interleaved_coded_array = np.array([0]*432, dtype = 'int16')
              self.Coded_array             = np.array([0]*432, dtype = 'int16')
           
          def general_work(self, input_items, output_items):
              in_index = 0
              out_index = 0

              while (len(input_items[0]) >= in_index + IN_STEP) and (len(output_items[0]) >= out_index + OUT_STEP) :

                  # "0" = 127, "1" = -127
                  if type(input_items[0][0]) == np.uint8:
                      for i in range(432):
                          self.Interleaved_coded_array[i] = -127 if input_items[0][in_index+i] else 127
                  else: #int16                   
                      self.Interleaved_coded_array[0:432] = input_items[0][in_index:in_index+432]
                                                              
                  #self.Frame_stealing = input_items[0][in_index + IN_STEP - 1]

                  if self.Frame_stealing :
                      tetraChDecoder.Desinterleaving_Signalling(self.Interleaved_coded_array[216:], self.Coded_array[216:])
                      self.Coded_array[:216] = self.Interleaved_coded_array[:216]
                  else:
                      tetraChDecoder.Desinterleaving_Speech(self.Interleaved_coded_array, self.Coded_array)

                  self.bfi1 = self.Frame_stealing
                  #if self.bfi1:
                  #    print(f"Frame Nb %d was stolen" %(self.Loop_counter+1))

                  bfi2 = tetraChDecoder.Channel_Decoding(self.first_pass, self.Frame_stealing, self.Coded_array, self.Reordered_array)
                  self.first_pass = False

                  if (self.Frame_stealing==0) and (self.bfi2==1):
                      self.bfi1 = 1

                  self.Loop_counter += 1
                  #if self.bfi2:
                  #    print(f"Frame Nb %d Bfi active" %(self.Loop_counter+1))

                  output_items[0][out_index] = self.bfi1
                  output_items[0][out_index+1:out_index+138] = self.Reordered_array[0:137]
                  output_items[0][out_index+138] = self.bfi2
                  output_items[0][out_index+139:out_index+276] = self.Reordered_array[137:274]

                  #if (not self.bfi1) and (not self.bfi2):
                  #    print(self.Loop_counter, "  full speech frame decoded ok")

                  in_index += IN_STEP
                  out_index += OUT_STEP
                  
              self.consume(0, in_index)
              return out_index
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Blockage
      - True: just throw samples away, do nothing
      - False: copy input items to output
      """

      import numpy as np
      from gnuradio import gr


      class blockage_cp(gr.basic_block):
          
          def __init__(self, mode=True):
              gr.basic_block.__init__(
                  self,
                  name='Transmit Gate',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.mode = mode

          def general_work(self, input_items, output_items):
              if self.mode:
                  self.consume(0, len(input_items[0]))
                  return 0
              
              consume_len = len(input_items[0]) if (len(output_items[0])>len(input_items[0])) else len(output_items[0]) 
              output_items [0][:consume_len] = input_items[0][:consume_len]
              self.consume (0, consume_len)
                  
              return consume_len
    mode: ptt_on
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Blockage
      - True: just throw samples away, do nothing
      - False: copy input items to output
      """

      import numpy as np
      from gnuradio import gr


      class blockage_real(gr.sync_block):
          
          def __init__(self, mode=True):
              gr.basic_block.__init__(
                  self,
                  name='Receive Gate',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.mode = mode

          def general_work(self, input_items, output_items):
              if self.mode:
                  self.consume(0, len(input_items[0]))
                  return 0

              consume_len = len(input_items[0]) if (len(output_items[0])>len(input_items[0])) else len(output_items[0]) 
              output_items[0][:consume_len] = input_items[0][:consume_len]
              self.consume(0, consume_len)
              return consume_len
    mode: not ptt_on
  states: {}
- name: epy_block_0_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      L_FRAME     = 240
      SERIAL_SIZE = 138
      PRM_SIZE    = 24

      synth = np.array([0]*L_FRAME, dtype ='int16')      #/* Synthesis              */
      parm  = np.array([0]*PRM_SIZE, dtype ='int16')     #/* Synthesis parameters   */
      serial= np.array([0]*SERIAL_SIZE, dtype ='int16')  #/* Serial stream          */

      class tetraSpDecoder(gr.basic_block):
          lib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Receiver/codec/tetraSrcDecoderLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.int16, 
                                                ndim=1,
                                                flags="C")
          lib.Bits2prm_Tetra.argtypes = [ND_POINTER, ND_POINTER]
          lib.Decod_Tetra.argtypes    = [ND_POINTER, ND_POINTER]
          lib.Post_Process.argtypes   = [ND_POINTER, c_int16]

          def Init_Decod_Tetra():
              tetraSpDecoder.lib.Init_Decod_Tetra()
              
          def Bits2prm_Tetra(serial, parm):
              tetraSpDecoder.lib.Bits2prm_Tetra(serial, parm)

          def Decod_Tetra(parm, synth):
              tetraSpDecoder.lib.Decod_Tetra(parm, synth)

          def Post_Process(synth, L_frame):    
              tetraSpDecoder.lib.Post_Process(synth, L_frame)

          
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Tetra ACELP\nSpeech Decoder',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[np.float32]
              )
              self.frame = 0

          def general_work(self, input_items, output_items):
              cod_ptr = 0
              raw_ptr = 0

              tetraSpDecoder.Init_Decod_Tetra()
              while (cod_ptr + SERIAL_SIZE <= len(input_items[0])) and (raw_ptr + L_FRAME <= len(output_items[0])):

                  for j in range (SERIAL_SIZE):
                      serial[j] = input_items[0][cod_ptr+j]
                      
                  cod_ptr += SERIAL_SIZE
                  self.frame +=1
                  
                  #print("frame= %d" %self.frame)
                  tetraSpDecoder.Bits2prm_Tetra(serial, parm)
                  tetraSpDecoder.Decod_Tetra(parm, synth)
                  tetraSpDecoder.Post_Process(synth, L_FRAME)

                  for j in range (L_FRAME):
                      output_items[0][raw_ptr+j] = synth[j] / 32768
                  
                  raw_ptr += L_FRAME
              self.consume(0, cod_ptr)
              return raw_ptr
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class Pi4DQPSK(gr.interp_block):
          # Create our raised-cosine filter
          num_taps = 11 * 2 + 1
          beta = 0.35
          Ts = 2
          t = np.arange(num_taps) - (num_taps-1) // 2
          h = np.sinc(t/Ts) * np.cos(np.pi*beta*t/Ts) / (1 - (2*beta*t/Ts)**2)
          preConvI = np.array([0] * 22, dtype = 'float32')
          preConvQ = np.array([0] * 22, dtype = 'float32')
          
          def __init__(self, envelope_in = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.interp_block.__init__(
                  self,
                  name='Pi4DQPSK 18kDibit-to-36kIQk',   	# will show up in GRC
                  in_sig=[np.uint8, np.uint8,],
                  out_sig=[np.complex64], interp = 2
              )
              self.interp = 2        
              self.cur_phase_index = 	0				# current phase index value S(0) = 1
              self.envelope_in = envelope_in
              
          def work(self, input_items, output_items):
              # Phase Index Change Table: corresponding to current phase (row 0-7) and current dibit value (column 0-3)
              # B2k_1,B2k:   00 01 10 11
                  
              phase_shift = (1, 3, 7, 5)

              # Phase value corresponding to Phase Index
              IQ_table = (( np.cos(np.pi/4 * 0) , np.sin(np.pi/4 * 0) ),
                          ( np.cos(np.pi/4 * 1) , np.sin(np.pi/4 * 1) ),
                          ( np.cos(np.pi/4 * 2) , np.sin(np.pi/4 * 2) ),
                          ( np.cos(np.pi/4 * 3) , np.sin(np.pi/4 * 3) ),
                          ( np.cos(np.pi/4 * 4) , np.sin(np.pi/4 * 4) ),
                          ( np.cos(np.pi/4 * 5) , np.sin(np.pi/4 * 5) ),
                          ( np.cos(np.pi/4 * 6) , np.sin(np.pi/4 * 6) ),
                          ( np.cos(np.pi/4 * 7) , np.sin(np.pi/4 * 7) ))

              # perform rrc filter
              tempI = np.array([0] * (len(input_items[0]) * 2), dtype='float32') # 22 = rrc_taps - 1
              tempQ = np.array([0] * (len(input_items[0]) * 2), dtype='float32') # 22 = rrc_taps - 1

              for i in range (0,len(input_items[0])):
                  if self.envelope_in:
                      input_dibit = input_items[0][i] & input_items[1][i]
                  else:
                      input_dibit = input_items[0][i]
                      
                  self.cur_phase_index += phase_shift[ input_dibit ]
                  if self.cur_phase_index >= 8:
                      self.cur_phase_index -= 8

                  if input_items[1][i] :
                      tempI[i*2] = IQ_table[ self.cur_phase_index ][0]
                      tempQ[i*2] = IQ_table[ self.cur_phase_index ][1]

              tempIconvolved = np.convolve(tempI, Pi4DQPSK.h) 
              tempQconvolved = np.convolve(tempQ, Pi4DQPSK.h)
              
              for i in range(len(Pi4DQPSK.h)-1):
                  tempIconvolved[i] += Pi4DQPSK.preConvI[i]
                  tempQconvolved[i] += Pi4DQPSK.preConvQ[i]

              for i in range(len(Pi4DQPSK.h)-1):
                  Pi4DQPSK.preConvI[-i-1] = tempIconvolved[-i-1]
                  Pi4DQPSK.preConvQ[-i-1] = tempQconvolved[-i-1]
              for i in range(len(input_items[0])*2):
                  output_items[0][i] = tempIconvolved [i] + 1j*tempQconvolved[i]
                                         
              return len(output_items[0])
    envelope_in: 'False'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      class blk(gr.basic_block):
          codingLib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Receiver/DmoDecoder/libs/codingLib.so') # class level loading lib

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.uint8, 
                                            ndim=1,
                                            flags="C")
          def service_mac(in_data, in_len, out_data):
              blk.codingLib.service_mac.argtypes = [blk.ND_POINTER, c_size_t, blk.ND_POINTER]
              blk.codingLib.service_mac.restype = c_size_t
              res = blk.codingLib.service_mac(in_data, in_len, out_data)
              return res


          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='DMO\nBurst SYNC',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

          def general_work(self, input_items, output_items):
              in_len = len(input_items[0])
              out_len = len(output_items[0])
              consume_len = in_len if (in_len < (out_len - 510)) else (out_len - 510)
              out_items = blk.service_mac(input_items[0], consume_len, output_items[0])
              self.consume(0, consume_len)
              return out_items
  states: {}
- name: freq_parameters
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: Frequency
    num_tabs: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_hz
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,12500,12500*0.2)
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '2000000'
    buffer_size: int(32768)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: frequency_hz+freq_adjust
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: frequency_hz-freq_offset_hz
    gain1: '''manual'''
    manual_gain1: '15'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    gain: decim/2
    interp: decim
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 36/80
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(samp_rate)/(float(decim)*float(channel_rate))
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,2,1,1
    legend: 'False'
    name: '"Receive IQ Constellation"'
    size: '2000'
    type: complex
  states: {}
- name: qtgui_ledindicator_0_0_1
  id: qtgui_ledindicator
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Tx
    offColor: gray
    state: ptt_on
  states: {}
- name: qtgui_ledindicator_0_0_1_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: qtgui_tab_widget_0
    label: Rx
    offColor: gray
    state: not ptt_on
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,2,1,1
    label0: Tx-Rx
    num_tabs: '1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    legend: 'False'
    name: '"Mic Transmit Audio "'
    size: 2040*2
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,3,1,2
    legend: 'False'
    name: '"Transmit IQ"'
    size: int(4*2040)
    srate: symbol_rate*2
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 1,3,1,2
    legend: 'False'
    name: '"Receive IQ"'
    size: int(4*2040)
    srate: symbol_rate*2
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: s18kDibit
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: s18kDibit_envelop
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: decoder_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: s18kDibit
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: s18kDibit_envelop
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: decoder_in
  states: {}

connections:
- [audio_source_0, '0', epy_block_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_linear_equalizer_0, '0', digital_diff_phasor_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, '0', virtual_sink_0, '0']
- [epy_block_0, '1', virtual_sink_0_0, '0']
- [epy_block_0_0, '0', epy_block_0, '0']
- [epy_block_0_0_0, '0', epy_block_0_2_0, '0']
- [epy_block_0_0_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [epy_block_0_1, '0', epy_block_0_0, '0']
- [epy_block_0_1, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0_2_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_1, '0', mmse_resampler_xx_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_1_0_0, '0']
- [epy_block_2, '0', epy_block_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', mmse_resampler_xx_0_0, '0']
- [iio_pluto_source_0, '0', epy_block_0_0_1, '0']
- [low_pass_filter_0_0, '0', iio_pluto_sink_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0_0, '0']
- [mmse_resampler_xx_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [mmse_resampler_xx_0_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [virtual_source_0, '0', epy_block_1, '0']
- [virtual_source_0_0, '0', epy_block_1, '1']
- [virtual_source_0_1, '0', epy_block_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
