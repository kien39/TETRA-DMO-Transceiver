options:
  parameters:
    generate_options: qt_gui
    id: s36kIQ_Encoder
    output_language: python
    title: s36kIQ_Encoder
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq_adjust
  id: variable_qtgui_range
  parameters:
    start: '-1500'
    step: '10'
    stop: '1500'
    value: '000'
  states: {}
- name: frequency_hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,0]'
    label: Frequency [Hz]
    type: real
    value: 390000000+3700
  states: {}
- name: num_tap
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 80000*decim
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '18000'
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/ctn008/tetraDMO-Transmitter/samples/TxDMO_s36kBit.uint8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samp_per_symbol
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: samp_per_symbol
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: symbol_rate*2
    type: byte
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1]+ [0]*(samp_per_symbol-1)'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class dmoBurst_iqMapper(gr.basic_block):  
          # Phase Index Change Table: corresponding to current phase (row 0-7) and current dibit value (column 0-3)
          # B2k_1,B2k:   00 01 10 11
          phase_shift = (1, 3, 7, 5)

          # Phase value corresponding to Phase Index
          IQ_table = (( np.cos(np.pi/4 * 0) , np.sin(np.pi/4 * 0) ),
                      ( np.cos(np.pi/4 * 1) , np.sin(np.pi/4 * 1) ),
                      ( np.cos(np.pi/4 * 2) , np.sin(np.pi/4 * 2) ),
                      ( np.cos(np.pi/4 * 3) , np.sin(np.pi/4 * 3) ),
                      ( np.cos(np.pi/4 * 4) , np.sin(np.pi/4 * 4) ),
                      ( np.cos(np.pi/4 * 5) , np.sin(np.pi/4 * 5) ),
                      ( np.cos(np.pi/4 * 6) , np.sin(np.pi/4 * 6) ),
                      ( np.cos(np.pi/4 * 7) , np.sin(np.pi/4 * 7) ))

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='dmoBurst_iqMapper',
                  in_sig=[np.uint8],
                  out_sig=[np.float32, np.float32]
              )
              self.cur_phase_index = 	0				# current phase index value S(0) = 1

          def general_work(self, input_items, output_items):
              if (len(input_items[0]) < 520) or (len(output_items[0]) < 510):
                  in_index = 0
                  out_index = 0
              else:
                  if ( input_items[0][0] ):   # active burst, either DSB, DNB or DNB_SF
                      for out_index in range (510):
                          self.cur_phase_index += dmoBurst_iqMapper.phase_shift[ input_items[0][out_index+10] ]
                          if self.cur_phase_index >= 8:
                              self.cur_phase_index -= 8
                          output_items[0][out_index] = dmoBurst_iqMapper.IQ_table[ self.cur_phase_index ][0]
                          output_items[1][out_index] = dmoBurst_iqMapper.IQ_table[ self.cur_phase_index ][1]
                  else:
                      for out_index in range (510):
                          output_items[0][out_index] = 0
                          output_items[1][out_index] = 0
                  in_index = 520
              self.consume(0, in_index)
              return out_index
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: int(510*2560/36)
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: samp_per_symbol
    ntaps: num_tap*samp_per_symbol
    samp_rate: samp_per_symbol*symbol_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: samp_per_symbol
    ntaps: num_tap*samp_per_symbol
    samp_rate: samp_per_symbol*symbol_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}

connections:
- [blocks_file_source_0_0_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_throttle2_0, '0', epy_block_1, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0_0, '0']
- [epy_block_1, '0', blocks_repeat_0, '0']
- [epy_block_1, '1', blocks_repeat_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_complex_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
